# Keil uVision project TinyUSB_Device_HID_Application.uvprojx, settings and files
target TinyUSB_Device_HID_Application (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: MM32F3273G9P MindMotion
  pack: MindMotion.MM32F3270_DFP.1.1.8
  cpu: IRAM(0x20000000,0x20000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Application +hex
  AfterMake: fromelf.exe --bin -o "@L.bin" "#L"
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=5 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c misc: --diag_suppress=1296,66
  c include: ..\..\TinyUSB_Device_HID_Application;..\..\..\..\..\Device\CMSIS\KEIL_Core;..\..\..\..\..\Device\MM32F327x\Include;..\..\..\..\..\Device\MM32F327x\HAL_Lib\Inc;..\..\..\tinyusb-0.16.0\src;..\..\..\tinyusb-0.16.0\hw;..\..\..\tinyusb-0.16.0\src\class\hid
  library: MicroLIB
  memory RVCT4: ROM 0x8004000 size 0x7c000
  memory RVCT9: RAM 0x20000000 size 0x20000
  link misc: --keep=*_cb
  group APP
    ../: main.c platform.c tud_dcd_port.c usb_descriptors.c tinyusb_device_hid_comp.c
  group DOC
    ../: readme.txt
  group HAL_LIB
    ../../../../../Device/MM32F327x/HAL_Lib/Src/: hal_adc.c hal_bkp.c hal_can.c hal_comp.c hal_crc.c hal_crs.c hal_dac.c hal_dbg.c hal_dma.c hal_exti.c hal_flash.c hal_fsmc.c hal_gpio.c hal_i2c.c hal_iwdg.c hal_misc.c hal_pwr.c hal_rcc.c hal_rtc.c hal_sdio.c hal_spi.c hal_tim.c hal_uart.c hal_uid.c hal_usbfs.c hal_ver.c hal_wwdg.c
  group STARTUP
    ../../../../../Device/MM32F327x/Source/: system_mm32f327x.c
    ../../../../../Device/MM32F327x/Source/KEIL_StartAsm/: startup_mm32f327x_keil.s
  group TinyUSB
    ../../../tinyusb-0.16.0/src/device/: usbd.c usbd_control.c
    ../../../tinyusb-0.16.0/src/: tusb.c
    ../../../tinyusb-0.16.0/src/common/: tusb_fifo.c
    ../../../tinyusb-0.16.0/src/class/hid/: hid_device.c
