# Keil uVision project Application.uvprojx, settings and files
target Application (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: MM32SPIN0230B3TV MindMotion
  pack: MindMotion.MM32SPIN0230_DFP.1.1.0
  cpu: IRAM(0x20000000,0x1000) IROM(0x08000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: Application +hex
  AfterMake: fromelf.exe --bin -o "@L.bin" "#L"
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\..\Application;..\..\Device\CMSIS\Core\Include;..\..\Device\MM32SPIN0230\Include;..\..\Device\MM32SPIN0230\HAL_Lib\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8001800 size 0x6800
  memory RVCT9: RAM 0x200000c0 size 0xf40
  group APP
    ../: main.c mm32spin0230_it.c usart_interrupt.c platform.c app_protocol.c
  group HAL_LIB
    ../../Device/MM32SPIN0230/HAL_Lib/src/: hal_adc.c hal_comp.c hal_dbg.c hal_dma.c hal_exti.c hal_flash.c hal_gpio.c hal_hwdiv.c hal_iwdg.c hal_misc.c hal_opamp.c hal_pwr.c hal_rcc.c hal_syscfg.c hal_tim.c hal_uid.c hal_usart.c
  group STARTUP
    ../../Device/MM32SPIN0230/Source/: system_mm32spin0230.c
    ../../Device/MM32SPIN0230/Source/KEIL_StartAsm/: startup_mm32spin0230_keil.s
