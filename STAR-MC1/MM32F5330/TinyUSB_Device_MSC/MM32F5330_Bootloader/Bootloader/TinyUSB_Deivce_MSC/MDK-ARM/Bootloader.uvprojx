# Keil uVision project Bootloader.uvprojx, settings and files
target USB_Deivce_MSC (6230000::V6.23::ARMCLANG)
  device: MM32F5333D7PV MindMotion
  pack: MindMotion.MM32F5330_DFP.0.5.1
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x20000) CPUTYPE("Star-MC1") FPU3(SFPU) DSP CLOCK(12000000) ELITTLE
  output: TinyUSB_MSC_Bootloader +hex
  AfterMake: .\crc_gen_keil.bat
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_STDPERIPH_DRIVER,  DCACHE_DISABLED
  c include: ..\..\TinyUSB_Deivce_MSC;..\..\..\Device\CMSIS\Core\Include;..\..\..\Device\MM32F5330\Include;..\..\..\Device\MM32F5330\HAL_Lib\inc;..\..\tinyusb-0.15.0\src;..\..\tinyusb-0.15.0\hw;..\SEGGER_RTT_V794b\RTT;..\SEGGER_RTT_V794b\Config;..\fatfs\source;..\fatfs\source\fsl_usb_disk;..\msd
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x7400
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: ..\..\..\Device\MM32F5330\Source\mm32f5330.sct
  link misc: --keep=*_cb
  group APP
    ../: main.c mm32f5330_it.c platform.c tud_dcd_port.c usb_descriptors.c tinyusb_device_msc.c msc_disk.c spi_master_flash_polling.c tim6_timebase.c crc32_algorithm.c boot.c gpio_key_input.c
  group HAL_LIB
    ../../../Device/MM32F5330/HAL_Lib/src/: hal_adc.c hal_bkp.c hal_comp.c hal_cordic.c hal_crcpoly.c hal_crs.c hal_dac.c hal_dbg.c hal_dma.c hal_exti.c hal_flash.c hal_flexcan.c hal_gpio.c hal_i2c.c hal_i3c.c hal_iwdg.c hal_lptim.c hal_lpuart.c hal_mds.c hal_misc.c hal_pwr.c hal_rcc.c hal_rtc.c hal_spi.c hal_sram.c hal_syscfg.c hal_tim.c hal_uart.c hal_uid.c hal_usart.c hal_usbfs.c hal_wwdg.c
  group STARTUP
    ../../../Device/MM32F5330/Source/: system_mm32f5330.c
    ../../../Device/MM32F5330/Source/KEIL_StartAsm/: startup_mm32f5330_keil.c
  group TinyUSB
    ../../tinyusb-0.15.0/src/device/: usbd.c usbd_control.c
    ../../tinyusb-0.15.0/src/: tusb.c
    ../../tinyusb-0.15.0/src/common/: tusb_fifo.c
    ../../tinyusb-0.15.0/src/class/msc/: msc_device.c
  group RTT
    ../SEGGER_RTT_V794b/RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
  group fatfs/souce
    ../fatfs/source/: diskio.c ff.c ffsystem.c ffunicode.c
  group msd
    ../msd/: host_msd_fatfs.c
  group fatfs/source/fsl_usb_disk
    ../fatfs/source/fsl_usb_disk/: fsl_usb_disk_bm.c
