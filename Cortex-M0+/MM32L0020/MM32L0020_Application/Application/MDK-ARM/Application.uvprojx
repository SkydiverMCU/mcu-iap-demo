# Keil uVision project Application.uvprojx, settings and files
target Application (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: MM32L0020B1T MindMotion
  pack: MindMotion.MM32L0020_DFP.0.9.1
  cpu: IRAM(0x20000000,0x00000800) IROM(0x08000000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Application +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,__VTOR_PRESENT
  c include: ..\..\Application;..\..\Device\CMSIS\Core\Include;..\..\Device\MM32L0020\Include;..\..\Device\MM32L0020\HAL_Lib\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8001400 size 0x6c00
  memory RVCT9: RAM 0x20000000 size 0x800
  group APP
    ../: main.c mm32l0020_it.c uart_interrupt.c platform.c app_protocol.c
  group HAL_LIB
    ../../Device/MM32L0020/HAL_Lib/src/: hal_adc.c hal_comp.c hal_crcep.c hal_dbg.c hal_exti.c hal_flash.c hal_gpio.c hal_i2c.c hal_iwdg.c hal_lptim.c hal_lpuart.c hal_misc.c hal_opamp.c hal_pwr.c hal_rcc.c hal_spi.c hal_syscfg.c hal_tim.c hal_uart.c hal_uid.c hal_wwdg.c
  group STARTUP
    ../../Device/MM32L0020/Source/: system_mm32l0020.c
    ../../Device/MM32L0020/Source/KEIL_StartAsm/: startup_mm32l0020_keil.s
