# Keil uVision project Bootloader.uvprojx, settings and files
target Bootloader (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: MM32F0163D7PV MindMotion
  pack: MindMotion.MM32F0160_DFP.1.0.0
  cpu: IRAM(0x20000000,0x00004000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: Bootloader +hex
  AfterMake: .\crc_gen_keil.bat
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\..\Bootloader;..\..\Device\CMSIS\KEIL_CORE;..\..\Device\MM32F0160\Include;..\..\Device\MM32F0160\HAL_lib\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x1400
  memory RVCT9: RAM 0x20000000 size 0x4000
  group APP
    ../: main.c mm32f0160_it.c uart_receiveridleframe_interrupt.c platform.c boot.c crc32_algorithm.c
  group DOC
    ../: readme.txt
  group HAL_LIB
    ../../Device/MM32F0160/HAL_lib/src/: hal_adc.c hal_bkp.c hal_comp.c hal_crc.c hal_crs.c hal_dbg.c hal_dma.c hal_exti.c hal_flash.c hal_flexcan.c hal_gpio.c hal_hwdiv.c hal_i2c.c hal_i3c.c hal_iwdg.c hal_lptim.c hal_lpuart.c hal_misc.c hal_pwr.c hal_rcc.c hal_rtc.c hal_spi.c hal_tim.c hal_uart.c hal_uid.c hal_usb.c hal_ver.c hal_wwdg.c
  group STARTUP
    ../../Device/MM32F0160/Source/: system_mm32f0160.c
    ../../Device/MM32F0160/Source/KEIL_StartAsm/: startup_mm32f0160_keil.s
