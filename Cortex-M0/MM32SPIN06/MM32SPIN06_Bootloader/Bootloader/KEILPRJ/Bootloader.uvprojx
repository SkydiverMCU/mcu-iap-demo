# Keil uVision project Bootloader.uvprojx, settings and files
target MM32Series (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: MM32F0133C7P MindMotion
  pack: MindMotion.MM32F0130_DFP.1.0.3
  cpu: IRAM(0x20000000,0x4000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: Bootloader +hex
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\..\Device\CMSIS\KEIL_Core;..\..\Device\MM32SPIN06xx_s\Include;..\..\Device\MM32SPIN06xx_s\HAL_Lib\Inc;..\USER;..\SYSTEM\DELAY;..\HARDWARE\UART;..\HARDWARE\LED;..\HARDWARE\BOOT
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x1400
  memory RVCT9: RAM 0x20000000 size 0x4000
  group STARTUP
    ../../Device/MM32SPIN06xx_s/Source/: system_mm32spin06xx_s.c
    ../../Device/MM32SPIN06xx_s/Source/KEIL_StartAsm/: startup_mm32spin06xx_s_keil.s
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/UART/: uart_txrx_interrupt.c
    ../HARDWARE/BOOT/: boot.c
  group SYSTEM
    ../SYSTEM/DELAY/: delay.c
  group USER
    ../USER/: main.c
  group HAL_Lib
    ../../Device/MM32SPIN06xx_s/HAL_Lib/Src/: hal_adc.c hal_bkp.c hal_can.c hal_comp.c hal_crc.c hal_dbg.c hal_div.c hal_dma.c hal_exti.c hal_flash.c hal_gpio.c hal_i2c.c hal_iwdg.c hal_misc.c hal_pwr.c hal_rcc.c hal_spi.c hal_tim.c hal_uart.c hal_uid.c hal_ver.c hal_wwdg.c
