# Keil uVision project Bootloader.uvprojx, settings and files
target TinyUSB_Device_MSC (6230000::V6.23::ARMCLANG)
  device: MM32F0163D7PV MindMotion
  pack: MindMotion.MM32F0160_DFP.1.0.0
  cpu: IRAM(0x20000000,0x00004000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: TinyUSB_MSC_Bootloader +hex
  AfterMake: .\crc_gen_keil.bat
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: USE_STDPERIPH_DRIVER
  c include: ..\..\TinyUSB_Deivce_MSC;..\..\..\Device\CMSIS\KEIL_CORE;..\..\..\Device\MM32F0160\Include;..\..\..\Device\MM32F0160\HAL_lib\inc;..\..\tinyusb-0.15.0\src;..\..\tinyusb-0.15.0\hw;..\..\tinyusb-0.15.0\src\common;..\..\tinyusb-0.15.0\src\device;..\..\tinyusb-0.15.0\src\class\msc;..\SEGGER_RTT_V794b\RTT;..\SEGGER_RTT_V794b\Config;..\fatfs\source;..\fatfs\source\fsl_usb_disk;..\msd
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x6800
  memory RVCT9: RAM 0x20000000 size 0x4000
  group APP
    ../: main.c mm32f0160_it.c platform.c tud_dcd_port.c usb_descriptors.c tinyusb_mass_storage.c msc_disk.c spi_master_polling.c tim14_timebase.c crc32_algorithm.c boot.c gpio_key_input.c
  group HAL_LIB
    ../../../Device/MM32F0160/HAL_lib/src/: hal_adc.c hal_bkp.c hal_comp.c hal_crc.c hal_crs.c hal_dbg.c hal_dma.c hal_exti.c hal_flash.c hal_flexcan.c hal_gpio.c hal_hwdiv.c hal_i2c.c hal_i3c.c hal_iwdg.c hal_lptim.c hal_lpuart.c hal_misc.c hal_pwr.c hal_rcc.c hal_rtc.c hal_spi.c hal_tim.c hal_uart.c hal_uid.c hal_usb.c hal_ver.c hal_wwdg.c
  group STARTUP
    ../../../Device/MM32F0160/Source/: system_mm32f0160.c
    ../../../Device/MM32F0160/Source/KEIL_StartAsm/: startup_mm32f0160_keil.s
  group TinyUSB
    ../../tinyusb-0.15.0/src/: tusb.c
    ../../tinyusb-0.15.0/src/device/: usbd.c usbd_control.c
    ../../tinyusb-0.15.0/src/common/: tusb_fifo.c
    ../../tinyusb-0.15.0/src/class/msc/: msc_device.c
  group RTT
    ../SEGGER_RTT_V794b/RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
  group fatfs/souce
    ../fatfs/source/: diskio.c ff.c ffsystem.c ffunicode.c
  group msd
    ../msd/: host_msd_fatfs.c
  group fatfs/source/fsl_usb_disk
    ../fatfs/source/fsl_usb_disk/: fsl_usb_disk_bm.c
