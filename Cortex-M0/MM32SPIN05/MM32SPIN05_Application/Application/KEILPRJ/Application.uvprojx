# Keil uVision project Application.uvprojx, settings and files
target Application (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: MM32SPIN05PF MindMotion
  pack: MindMotion.MM32SPIN0x_DFP.1.0.8
  cpu: IRAM(0x20000000,0x1000) IROM(0x08000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: Application +hex
  AfterMake: fromelf.exe --bin -o "@L.bin" "#L"
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\..\Device\CMSIS\KEIL_Core;..\..\Device\MM32SPIN0x_q\Include;..\..\Device\MM32SPIN0x_q\HAL_Lib\Inc;..\USER;..\SYSTEM\SYS;..\SYSTEM\DELAY;..\HARDWARE\UART;..\HARDWARE\LED;..\HARDWARE\BOOT;..\HARDWARE\TIM
  library: MicroLIB
  memory RVCT4: ROM 0x8001800 size 0x6800
  memory RVCT9: RAM 0x200000c0 size 0xf40
  group STARTUP
    ../../Device/MM32SPIN0x_q/Source/: system_mm32spin0x_q.c
    ../../Device/MM32SPIN0x_q/Source/KEIL_StartAsm/: startup_mm32spin0x_q_keil.s
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/UART/: uart_txrx_interrupt.c
    ../HARDWARE/TIM/: tim.c
    ../HARDWARE/BOOT/: app_protocol.c
  group SYSTEM
    ../SYSTEM/DELAY/: delay.c
  group USER
    ../USER/: main.c
  group HAL_Lib
    ../../Device/MM32SPIN0x_q/HAL_Lib/Src/: hal_adc.c hal_comp.c hal_crc.c hal_dbg.c hal_div.c hal_dma.c hal_exti.c hal_flash.c hal_gpio.c hal_i2c.c hal_iwdg.c hal_misc.c hal_pwr.c hal_rcc.c hal_spi.c hal_tim.c hal_uart.c hal_uid.c hal_ver.c hal_wwdg.c
