# Keil uVision project Application.uvprojx, settings and files
target Application (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: MM32L0136C7P MindMotion
  pack: MindMotion.MM32L0130_DFP.1.1.2
  cpu: IRAM(0x20000000,0x2000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M0") CLOCK(12000000)
  output: Application +hex
  AfterMake: fromelf.exe --bin -o "@L.bin" "#L"
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,__VTOR_PRESENT
  c include: ..\..\Application;..\..\Device\CMSIS\Core\Include;..\..\Device\MM32L0180\Include;..\..\Device\MM32L0180\HAL_Lib\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8001800 size 0x3e800
  memory RVCT9: RAM 0x20000000 size 0x6000
  group APP
    ../: main.c platform.c mm32l0180_it.c usart_interrupt.c
  group DOC
    ../: readme.txt
  group HAL_LIB
    ../../Device/MM32L0180/HAL_Lib/Src/: hal_adc.c hal_aes.c hal_comp.c hal_crcpoly.c hal_dbg.c hal_dma.c hal_dmamux.c hal_exti.c hal_flash.c hal_gpio.c hal_i2c.c hal_irm.c hal_iwdg.c hal_lptim.c hal_lpuart.c hal_misc.c hal_pwr.c hal_rcc.c hal_rtc.c hal_slcd.c hal_spi.c hal_syscfg.c hal_tim.c hal_uid.c hal_usart.c
  group STARTUP
    ../../Device/MM32L0180/Source/: system_mm32l0180.c
    ../../Device/MM32L0180/Source/KEIL_StartAsm/: startup_mm32l0180_keil.s
