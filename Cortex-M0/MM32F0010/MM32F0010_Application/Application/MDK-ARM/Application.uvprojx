# Keil uVision project Application.uvprojx, settings and files
target Application (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: MM32F0010A1T MindMotion
  pack: MindMotion.MM32F0010_DFP.1.0.6
  cpu: IRAM(0x20000000,0x00000800) IROM(0x08000000,0x00004000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: Application +hex
  AfterMake: fromelf.exe --bin -o "@L.bin" "#L"
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,__VTOR_PRESENT
  c include: ..\..\Application;..\..\Device\CMSIS\KEIL_Core;..\..\Device\MM32F0010\Include;..\..\Device\MM32F0010\HAL_Lib\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8001400 size 0x2c00
  memory RVCT9: RAM 0x200000c0 size 0x740
  group APP
    ../: main.c mm32f0010_it.c uart_interrupt.c platform.c
  group HAL_LIB
    ../../Device/MM32F0010/HAL_Lib/Src/: hal_adc.c hal_crc.c hal_dbg.c hal_exti.c hal_flash.c hal_gpio.c hal_i2c.c hal_iwdg.c hal_misc.c hal_pwr.c hal_rcc.c hal_spi.c hal_tim.c hal_uart.c hal_uid.c hal_ver.c hal_wwdg.c
  group STARTUP
    ../../Device/MM32F0010/Source/: system_mm32f0010.c
    ../../Device/MM32F0010/Source/KEIL_StartAsm/: startup_mm32f0010_keil.s
