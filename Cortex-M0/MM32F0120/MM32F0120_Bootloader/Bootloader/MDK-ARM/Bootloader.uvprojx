# Keil uVision project Bootloader.uvprojx, settings and files
target Bootloader (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: MM32F0121C6PV MindMotion
  pack: MindMotion.MM32F0120_DFP.0.9.3
  cpu: IRAM(0x20000000,0x00002000) IROM(0x08000000,0x00010000) IROM2(0x1fe00000,0x00000C00) CPUTYPE("Cortex-M0") CDECP(0) CLOCK(12000000) ELITTLE
  output: Bootloader +hex
  c flags: Optim=2 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\..\Bootloader;..\..\Device\CMSIS\Core\Include;..\..\Device\MM32F0120\Include;..\..\Device\MM32F0120\HAL_Lib\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x1400
  memory RVCT5: ROM 0x1fe00000 size 0xc00
  memory RVCT9: RAM 0x20000000 size 0x2000
  group APP
    ../: main.c platform.c boot.c usart_interrupt.c mm32f0120_it.c
  group HAL_LIB
    ../../Device/MM32F0120/HAL_Lib/src/: hal_adc.c hal_bkp.c hal_comp.c hal_crc.c hal_csm.c hal_dbg.c hal_dma.c hal_exti.c hal_flash.c hal_gpio.c hal_hwdiv.c hal_i2c.c hal_iwdg.c hal_misc.c hal_pwr.c hal_rcc.c hal_rtc.c hal_spi.c hal_syscfg.c hal_tim.c hal_uid.c hal_usart.c
  group STARTUP
    ../../Device/MM32F0120/Source/: system_mm32f0120.c
    ../../Device/MM32F0120/Source/KEIL_StartAsm/: startup_mm32f0120_keil.s
