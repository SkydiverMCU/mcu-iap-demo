# Keil uVision project Bootloader.uvprojx, settings and files
target Bootloader (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: MM32F0273D8P MindMotion
  pack: MindMotion.MM32F0270_DFP.0.1.1
  cpu: IRAM(0x20000000,0x4000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: Bootloader +hex
  AfterMake: .\crc_gen_keil.bat
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\..\Device\CMSIS\KEIL_Core;..\..\Device\MM32F0270\Include;..\..\Device\MM32F0270\HAL_Lib\Inc;..\USER;..\SYSTEM\DELAY;..\HARDWARE\UART;..\HARDWARE\LED;..\HARDWARE\BOOT
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x1400
  memory RVCT9: RAM 0x20000000 size 0x4000
  group STARTUP
    ../../Device/MM32F0270/Source/: system_mm32f0270.c
    ../../Device/MM32F0270/Source/KEIL_StartAsm/: startup_mm32f0270_keil.s
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/UART/: uart_txrx_idleframe_interrupt.c
  group SYSTEM
    ../SYSTEM/DELAY/: delay.c
  group USER
    ../USER/: main.c
    ../HARDWARE/BOOT/: boot.c crc32_algorithm.c
  group HAL_Lib
    ../../Device/MM32F0270/HAL_Lib/Src/: hal_adc.c hal_bkp.c hal_can.c hal_comp.c hal_crc.c hal_crs.c hal_dac.c hal_dbg.c hal_div.c hal_dma.c hal_exti.c hal_flash.c hal_gpio.c hal_i2c.c hal_iwdg.c hal_lptim.c hal_lpuart.c hal_misc.c hal_pwr.c hal_rcc.c hal_rtc.c hal_spi.c hal_tim.c hal_uart.c hal_uid.c hal_ver.c hal_wwdg.c
