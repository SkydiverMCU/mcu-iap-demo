# Keil uVision project Bootloader.uvprojx, settings and files
target Bootloader (6230000::V6.23::ARMCLANG)
  device: MM32F5277E7PV MindMotion
  pack: MindMotion.MM32F5277E_DFP.1.3.0
  cpu: IRAM(0x30000000,0x1C000) IROM(0x08000000,0x40000) CPUTYPE("Star-MC1") FPU3(SFPU) DSP CLOCK(12000000) ELITTLE
  output: UART_ReceiverIdleFrame_Interrupt +hex
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=3
  c define: USE_STDPERIPH_DRIVER,CUSTOM_HSE_VAL,ICACHE_DISABLED,DCACHE_DISABLED
  c include: ..\..\Bootloader;..\..\Device\CMSIS\Core\Include;..\..\Device\MM32F5270\Include;..\..\Device\MM32F5270\HAL_Lib\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x1400
  memory RVCT9: RAM 0x30000000 size 0x1c000
  scatter file: ..\..\Device\MM32F5270\Source\MM32F5270.sct
  group APP
    ../: main.c mm32f5270_it.c uart_receiveridleframe_interrupt.c platform.c boot.c
  group DOC
    ../: readme.txt
  group HAL_LIB
    ../../Device/MM32F5270/HAL_Lib/Src/: hal_adc.c hal_bkp.c hal_comp.c hal_cordic.c hal_crcpoly.c hal_crs.c hal_dac.c hal_dbg.c hal_dma.c hal_enet.c hal_exti.c hal_flash.c hal_flexcan.c hal_fsmc.c hal_gpio.c hal_i2c.c hal_iwdg.c hal_lptim.c hal_lpuart.c hal_mds.c hal_misc.c hal_pwr.c hal_qspi.c hal_rcc.c hal_rtc.c hal_spi.c hal_syscfg.c hal_tim.c hal_uart.c hal_uid.c hal_usbfs.c hal_wwdg.c
  group STARTUP
    ../../Device/MM32F5270/Source/: system_mm32f5270.c
    ../../Device/MM32F5270/Source/KEIL_StartAsm/: startup_mm32f5270_keil.c
