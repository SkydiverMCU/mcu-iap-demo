# Keil uVision project I2C_Master.uvprojx, settings and files
target MM32Series (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: MM32F0144C6PV MindMotion
  pack: MindMotion.MM32F0140_DFP.1.2.3
  cpu: IRAM(0x20000000,0x00002000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: I2C_Master +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER  __CC_ARM
  c include: ..\Device\MM32F0140\Include;..\Device\MM32F0140\HAL_Lib\Inc;..\Device\CMSIS\KEIL_Core;..\USER;..\SYSTEM\UART;..\SYSTEM\SYS;..\SYSTEM\DELAY;..\HARDWARE\LED;..\HARDWARE\I2C
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group STARTUP
    ../Device/MM32F0140/Source/: system_mm32f0140.c
    ../Device/MM32F0140/Source/KEIL_StartAsm/: startup_mm32f0140_keil.s
  group HARDWARE
    ../HARDWARE/I2C/: i2c.c
    ../HARDWARE/LED/: led.c
  group SYSTEM
    ../SYSTEM/DELAY/: delay.c
    ../SYSTEM/UART/: uart.c
  group USER
    ../USER/: main.c
  group HAL_Lib
    ../Device/MM32F0140/HAL_Lib/Src/: hal_adc.c hal_comp.c hal_crc.c hal_dbg.c hal_div.c hal_dma.c hal_exti.c hal_flash.c hal_flexcan.c hal_gpio.c hal_i2c.c hal_iwdg.c hal_misc.c hal_pwr.c hal_rcc.c hal_spi.c hal_tim.c hal_uart.c hal_uid.c hal_ver.c hal_wwdg.c
