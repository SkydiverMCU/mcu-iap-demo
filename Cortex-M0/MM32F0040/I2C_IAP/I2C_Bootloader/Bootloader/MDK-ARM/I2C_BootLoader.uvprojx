# Keil uVision project I2C_BootLoader.uvprojx, settings and files
target I2C_BootLoader (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: MM32F0040B1T MindMotion
  pack: MindMotion.MM32F0040_DFP.0.0.3
  cpu: IRAM(0x20000000,0x00001000) IROM(0x08000000,0x00008000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: I2C_BootLoader +hex
  AfterMake: fromelf.exe --bin -o "@L.bin" "#L"
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\..\Device\CMSIS\KEIL_Core;..\..\Device\MM32F0040\Include;..\..\Device\MM32F0040\HAL_Lib\Inc;..\USER\inc;..\APP\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x1000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group USER
    ../USER/: main.c mm32f0040_it.c
  group APP
    ../APP/: i2c.c boot.c
  group HAL_LIB
    ../../Device/MM32F0040/HAL_Lib/Src/: hal_adc.c hal_comp.c hal_crc.c hal_dbg.c hal_div.c hal_dma.c hal_exti.c hal_flash.c hal_gpio.c hal_i2c.c hal_iwdg.c hal_misc.c hal_pwr.c hal_rcc.c hal_spi.c hal_tim.c hal_uart.c hal_uid.c hal_ver.c hal_wwdg.c
  group STARTUP
    ../../Device/MM32F0040/Source/: system_mm32f0040.c
    ../../Device/MM32F0040/Source/KEIL_StartAsm/: startup_mm32f0040_keil.s
