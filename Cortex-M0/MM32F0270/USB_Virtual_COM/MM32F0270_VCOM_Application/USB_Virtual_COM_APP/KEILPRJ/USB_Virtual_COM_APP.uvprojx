# Keil uVision project USB_Virtual_COM_APP.uvprojx, settings and files
target MM32Series (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: MM32F0273D8P MindMotion
  pack: MindMotion.MM32F0270_DFP.0.1.1
  cpu: IRAM(0x20000000,0x4000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: Application +hex
  AfterMake: fromelf.exe --bin -o "@L.bin" "#L"
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\..\Device\CMSIS\KEIL_Core;..\..\Device\MM32F0270\Include;..\..\Device\MM32F0270\HAL_Lib\Inc;..\USB_User\inc;..\USB_lib\inc;..\SYSTEM\UART;..\SYSTEM\SYS;..\SYSTEM\DELAY;..\HARDWARE\UART_NVIC;..\HARDWARE\LED
  library: MicroLIB
  memory RVCT4: ROM 0x8003000 size 0x1d400
  memory RVCT9: RAM 0x200000c0 size 0x3f40
  group STARTUP
    ../../Device/MM32F0270/Source/: system_mm32f0270.c
    ../../Device/MM32F0270/Source/KEIL_StartAsm/: startup_mm32f0270_keil.s
  group HAL_Lib
    ../../Device/MM32F0270/HAL_Lib/Src/: hal_adc.c hal_bkp.c hal_can.c hal_comp.c hal_crc.c hal_crs.c hal_dac.c hal_dbg.c hal_div.c hal_dma.c hal_exti.c hal_flash.c hal_gpio.c hal_i2c.c hal_iwdg.c hal_lptim.c hal_lpuart.c hal_misc.c hal_pwr.c hal_rcc.c hal_rtc.c hal_spi.c hal_tim.c hal_uart.c hal_uid.c hal_ver.c hal_wwdg.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/UART_NVIC/: uart_nvic.c
  group SYSTEM
    ../SYSTEM/DELAY/: delay.c
    ../SYSTEM/SYS/: sys.c
    ../SYSTEM/UART/: uart.c
  group USB_lib
    ../USB_lib/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c
  group USB_User
    ../USB_User/src/: hw_config.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c
  group USER
    ../USER/: main.c mm32f0270_it.c
