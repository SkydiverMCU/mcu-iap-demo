# Keil uVision project I2C_Slave.uvprojx, settings and files
target MM32Series (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: MM32F0020B1T MindMotion
  pack: MindMotion.MM32F0020_DFP.0.0.1
  cpu: IRAM(0x20000000,0x00000800) IROM(0x08000000,0x00008000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: I2C_Slave +hex
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER  __CC_ARM
  c include: ..\..\Device\CMSIS\KEIL_Core;..\..\Device\MM32F0020\Include;..\..\Device\MM32F0020\HAL_Lib\Inc;..\USER;..\SYSTEM\UART;..\SYSTEM\SYS;..\SYSTEM\DELAY;..\HARDWARE\LED;..\HARDWARE\I2C;..\HARDWARE\BOOT
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x800
  group STARTUP
    ../../Device/MM32F0020/Source/: system_mm32f0020.c
    ../../Device/MM32F0020/Source/KEIL_StartAsm/: startup_mm32f0020_keil.s
  group HARDWARE
    ../HARDWARE/I2C/: i2c.c
    ../HARDWARE/LED/: led.c
  group SYSTEM
    ../SYSTEM/DELAY/: delay.c
    ../SYSTEM/SYS/: sys.c
    ../SYSTEM/UART/: uart.c
  group USER
    ../USER/: main.c
    ../HARDWARE/BOOT/: boot.c
  group HAL_Lib
    ../../Device/MM32F0020/HAL_Lib/Src/: hal_adc.c hal_crc.c hal_dbg.c hal_exti.c hal_flash.c hal_gpio.c hal_i2c.c hal_iwdg.c hal_misc.c hal_pwr.c hal_rcc.c hal_spi.c hal_tim.c hal_uart.c hal_uid.c hal_ver.c hal_wwdg.c
