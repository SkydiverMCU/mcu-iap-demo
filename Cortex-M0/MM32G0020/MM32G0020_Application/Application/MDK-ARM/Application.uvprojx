# Keil uVision project Application.uvprojx, settings and files
target Application (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: MM32G0020B1T MindMotion
  pack: MindMotion.MM32G0020_DFP.0.5.0
  cpu: IRAM(0x20000000,0x00000800) IROM(0x08000000,0x00008000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: Application +hex
  AfterMake: fromelf.exe --bin -o "@L.bin" "#L"
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\..\Application;..\..\Device\CMSIS\Core\Include;..\..\Device\MM32G0020\Include;..\..\Device\MM32G0020\HAL_Lib\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8001800 size 0x6800
  memory RVCT9: RAM 0x200000c0 size 0x740
  group APP
    ../: main.c mm32g0020_it.c uart_receiveridleframe_interrupt.c platform.c app_protocol.c
  group HAL_LIB
    ../../Device/MM32G0020/HAL_Lib/src/: hal_adc.c hal_crc.c hal_dbg.c hal_exti.c hal_flash.c hal_gpio.c hal_i2c.c hal_iwdg.c hal_misc.c hal_pwr.c hal_rcc.c hal_spi.c hal_syscfg.c hal_tim.c hal_uart.c hal_uid.c
  group STARTUP
    ../../Device/MM32G0020/Source/: system_mm32g0020.c
    ../../Device/MM32G0020/Source/KEIL_StartAsm/: startup_mm32g0020_keil.s
